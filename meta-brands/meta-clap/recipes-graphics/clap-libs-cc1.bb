SRCDATE = "20180411"

require clap-libs.inc

SRC_URI[md5sum] = "a86a04f6c26d778cf4090df509d737fb"
SRC_URI[sha256sum] = "977693df30f812186e38810ceaf31778b5388fc7c2b6076bd87a12e9ecb16a0e"
