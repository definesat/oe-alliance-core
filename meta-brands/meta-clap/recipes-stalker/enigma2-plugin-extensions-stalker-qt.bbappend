VER = "-clap"

SRC_URI = "git://github.com/definesat/e2plugins.git;protocol=git"

SRCREV = "1fa7f9660c549d71f420a8698b6740712a632d47"

