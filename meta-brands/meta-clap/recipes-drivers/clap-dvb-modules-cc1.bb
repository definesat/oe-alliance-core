KV = "4.4.35"
SRCDATE = "20180426"

require clap-dvb-modules.inc

SRC_URI[md5sum] = "2dd9048816758c4d617dedae25951541"
SRC_URI[sha256sum] = "dbe8d6448034b34f356180c54819f8f69f399f942be043c35af96befe594cf32"
